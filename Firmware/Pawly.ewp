# IAR project Pawly.ewp, settings and files
configuration Debug-Slave (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: APSLAVE; USE_STDPERIPH_DRIVER; STM32F051; USE_STM320518_EVAL; USE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCIncludePath2: ; include\; Library\STM32F0xx_StdPeriph_Lib_V1.3.1\Libraries\STM32F0xx_StdPeriph_Driver\inc; Library\STM32F0xx_StdPeriph_Lib_V1.3.1\Libraries\CMSIS\Device\ST\STM32F0xx\Include; Library\STM32F0xx_StdPeriph_Lib_V1.3.1\Libraries\CMSIS\Include; Library\STM32F0xx_StdPeriph_Lib_V1.3.1\Libraries\STM32F0xx_CPAL_Driver\inc; Library\STM32F0xx_StdPeriph_Lib_V1.3.1\Utilities\STM32_EVAL\Common; Library\STM32F0xx_StdPeriph_Lib_V1.3.1\Utilities\STM32_EVAL\STM320518_EVAL
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: APbeacon_firmware.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: stm32f030_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: main.c stm32f0xx_it.c UART.c utility.c
  group Library
    Library/STM32F0xx_StdPeriph_Lib_V1.3.1/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
